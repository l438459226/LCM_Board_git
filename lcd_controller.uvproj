# Keil uVision project lcd_controller.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FHD_NT35596 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\USER;.\CMSIS;.\fatfs;.\LCD_DRV;.\USER\User\sdcard;.\USER\User\usart;.\FWlib\CMSIS;.\STM32_USB-FS-Device_Driver\inc;.\HID;.\USER\User\USMART;.\SYSTEM\delay;.\MALLOC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTCODE
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./USER/: main.c stm32f10x_it.c SysTick.c ssd2828.c in_img.c key.lib showtext.c gxnussd2828.c bmp.c sdcard.c user.c gxnu.c
    ./USER/User/sdcard/: bsp_sdio_sdcard.c
    ./USER/User/usart/: bsp_usart1.c
    ./SYSTEM/delay/: delay.c
  group FWlib
    ./FWlib/src/: stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_dma.c misc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_exti.c
  group CMSIS
    ./FWlib/CMSIS/: core_cm3.c system_stm32f10x.c
  group FATFS
    ./fatfs/: diskio.c ff.c
  group LCD_DRV
    ./LCD_DRV/: lcd_drv.lib
  group STM32_USB-FS-Device_Driver
    ./STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group HID
    ./HID/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group usmart
    ./USER/User/USMART/: pc_com.c usmart.c usmart_config.c usmart_str.c
  group LCM
    ./LCM/: YT70F21X0.c YT52F10A1.c YT55F96A6.c TD4310.c
  group malloc
    ./MALLOC/: malloc.c
